# Keil uVision project acro_only.uvprojx, settings and files
target H345 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: Mini58ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: h345 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --fpmode=fast
  c include: .\src;..\Library\CMSIS\Include;..\Library\Device\Nuvoton\Mini58Series\CMSIS\Include;..\Library\Device\Nuvoton\Mini58Series\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./acro_only/: pid_acro_only.c control_acro_only.c main_acro_only.c
    ./src/: buzzer.c gestures.c rx_bayang_protocol.c rx_bayang_protocol_ble.c rx_bayang_ble_app.c rx_bayang_protocol_telemetry.c rx_cg023_protocol.c rx_h7_protocol.c rx_cx10blue_protocol.c led.c rgb_led.c sixaxis.c motorcurve.c util.c stickvector.c imu.c filter.cpp config.h defines.h hardware.h debug.h
  group drv
    ./src/: drv_adc.c drv_clk.c drv_gpio.c drv_i2c.c drv_pwm.c drv_esc.c drv_dshot.c drv_serial.c drv_spi.c drv_spi_3wire.c drv_spi_none.c drv_time.c drv_xn297_3wire.c drv_xn297.c drv_hw_i2c.c drv_rgb.c
  group Startup
    ../Library/Device/Nuvoton/Mini58Series/CMSIS/armcc/: startup_Mini58Series.s
  group Peripherals
    ../Library/Device/Nuvoton/Mini58Series/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group SystemInit
    ../Library/Device/Nuvoton/Mini58Series/CMSIS/: system_Mini58Series.c
