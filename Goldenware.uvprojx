# Keil uVision project Goldenware.uvprojx, settings and files
target H345 (6140000::V6.14::ARMCLANG)
  device: Mini58ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.8
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Goldenware +hex
  c flags: Optim=4 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: .\Library\CMSIS\Include;.\Library\Device\Nuvoton\Mini58Series\CMSIS\Include;.\Library\Device\Nuvoton\Mini58Series\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Device
    ./Library/Device/Nuvoton/Mini58Series/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c spi.c timer.c uart.c wdt.c sys.c wwdt.c retarget.c
    ./Library/Device/Nuvoton/Mini58Series/CMSIS/armcc/: startup_Mini58Series.s
    ./Library/Device/Nuvoton/Mini58Series/CMSIS/: system_Mini58Series.c
  group Goldenware
    ./Goldenware/: main.cpp
    ./Goldenware/Common/: printf.cpp
