# Keil uVision project Goldenware_H8.uvprojx, settings and files
target H8 (6140000::V6.14::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Goldenware
  AfterMake: fromelf --bin ".\Build\Objects\@L.axf" --output ".\Build\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Build\Objects\@L.axf" --output ".\Build\Objects\@L.txt"
  c flags: Optim=4 OneElfS=1 v6LangP=3 wLevel=3
  c misc: -Wno-c++17-extensions
  c include: .\Library\CMSIS\Include;.\Library\Device\Panchip\PN020Series\CMSIS\Include;.\Library\Device\Panchip\PN020Series\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_PN020series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Device
    ./Library/Device/Panchip/PN020Series/CMSIS/Source/: system_PN020Series.c
    ./Library/Device/Panchip/PN020Series/CMSIS/Source/ARM/: startup_PN020Series.s
    ./Library/Device/Panchip/PN020Series/StdDriver/src/: clk.c gpio.c sys.c uart.c retarget.c pwm.c
  group Goldenware
    ./Goldenware/: main.cpp
